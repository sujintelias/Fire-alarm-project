# Keil uVision project my lcd.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: my lcd
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../lcd/: lcdPgm.c
    ../header/: lcd.c
    ./: lcd.h fire n bzr.c delay.c delay.h uart.h uart.c
